<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\gian-connection.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>